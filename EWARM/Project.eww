<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ECU_Dianteira_MR26.ewp</path>
  </project>
  <batchBuild />
</workspace>
